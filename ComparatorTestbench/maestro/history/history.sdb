<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 27 10:31:39 2026</timestamp>
			<uuid>{0df87d4b-bc3f-40b4-bd4c-c196bf40d8ac}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/top/students/UNGRAD/ECE/tiger131/home/ECE331/TSMC_Cadence/ECE571/ECE571/ComparatorTestbench/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/top/students/UNGRAD/ECE/tiger131/home/ECE331/TSMC_Cadence/ECE571/ECE571/ComparatorTestbench/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/top/students/UNGRAD/ECE/tiger131/home/simulation/ECE571/ComparatorTestbench/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/ECE571/ComparatorTestbench/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
