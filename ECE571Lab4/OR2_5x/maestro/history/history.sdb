<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Feb 18 15:59:07 2026</timestamp>
			<uuid>{fc99ed00-febb-47e9-aca9-3330aefb5698}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/top/students/UNGRAD/UE/tom2002/home/ECE571/TSMC_Cadence/Lab_01/OR2_5x/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/top/students/UNGRAD/UE/tom2002/home/ECE571/TSMC_Cadence/Lab_01/OR2_5x/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/top/students/UNGRAD/UE/tom2002/home/simulation/Lab_01/OR2_5x/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Lab_01/OR2_5x/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
